# Keil uVision project F407-Balance.uvprojx, settings and files
target F407-Balance (6210000::V6.21::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(168000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F407-Balance +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./BSP;./APP;./Algorithm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c tim.c
    ../Core/Inc/: tim.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Algorithm
    ./Algorithm/: Emm_V5.c Emm_V5.h PID.c PID.h Track_PID.c Track_PID.h
  group APP
    ./APP/: Balance_Control.c Balance_Control.h Motor_Calibration.c Motor_Calibration.h Motor_Command.c Motor_Command.h Telemetry.c Telemetry.h OLED_Display.c OLED_Display.h LineTrack_Control.c LineTrack_Control.h UI_Menu.c UI_Menu.h
  group BSP
    ./BSP/: Camera.c Camera.h JY901S.c JY901S.h UART_DMA.c UART_DMA.h Motor_Feedback.c Motor_Feedback.h OLED.c OLED.h Track_Sensor.c Track_Sensor.h Track_Motor.c Track_Motor.h Track_Encoder.c Track_Encoder.h Track_Keys.c Track_Keys.h
software components: CMSIS:CORE 5.6.0
