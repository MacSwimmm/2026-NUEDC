# Keil uVision project G3507-BASE.uvprojx, settings and files
target G3507-BASE (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: G3507_BASE +hex
  BeforeMake: cmd.exe /C call "$P..\tools\run_sysconfig_keil.bat" "$P.." G3507-BASE.syscfg
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..;..\APP;..\BSP;..\Algorithm;C:\ti\mspm0_sdk_2_01_00_03\source\third_party\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_01_00_03\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Startup & SysConfig
    ../: G3507-BASE.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group APP
    ../APP/: main.c app_config.h Car_Control.c Car_Control.h Race_Control.c Race_Control.h Telemetry_Stream.c Telemetry_Stream.h PID_Tuner.c PID_Tuner.h Display.c Display.h
  group BSP
    ../BSP/: bsp_config.h Board.c Board.h Motor.c Motor.h Encoder.c Encoder.h TrackSensor.c TrackSensor.h Key.c Key.h Buzzer.c Buzzer.h Serial.c Serial.h JY901S.c JY901S.h OLED.c OLED.h oledfont.h
  group Algorithm
    ../Algorithm/: PID.c PID.h LineTrack.c LineTrack.h
  group Driverlib
    C:/ti/mspm0_sdk_2_01_00_03/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
